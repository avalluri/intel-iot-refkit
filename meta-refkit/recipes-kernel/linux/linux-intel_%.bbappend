FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://neard-usb.cfg"
SRC_URI += "file://connman.cfg"
