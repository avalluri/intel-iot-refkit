EXTRA_OECONF += " --disable-neard"
